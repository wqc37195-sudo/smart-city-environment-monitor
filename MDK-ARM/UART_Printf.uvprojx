# Keil uVision project UART_Printf.uvprojx, settings and files
target UART_Printf (6160000::V6.16::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: UART_Printf +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WL55xx,CORE_CM4
  c include: ../Inc;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/STM32WLxx_Nucleo;../Middlewares/Third_Party/SubGHz_Phy;../Utilities/trace/adv_trace;../Utilities/misc;../Utilities/sequencer;../Utilities/timer;../Utilities/lpm/tiny_lpm;../Middlewares/Third_Party/SubGHz_Phy/radio_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User
    ../Src/: dht11.c bmp280.c ssd1306.c bh1750.c gp2y1010.c data_log.c chart.c lora_tx.c mic.c soft_i2c.c sgp30.c main.c gpio.c adc.c i2c.c subghz.c stm32_lpm_if.c sys_app.c app_subghz_phy.c subghz_phy_app.c radio_board_if.c timer_if.c usart_if.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wlxx.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/radio_driver/: lr_fhss_mac.c radio.c radio_driver.c radio_fw.c wl_lr_fhss.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
